# Repository Jstn1321/ChuaEncrypt

File README.md:

<h1 align="center">C.H.A.S.E.R</h1>

<h4 align="center">CHAotic Secure Encryption for Real-time audio</h4>

<h1></h1>

<p align="center">
  <a href="#abstract">Abstract</a> •
  <a href="#methodology">Methodology</a> • 
  <a href="#data">Data</a> •
  <a href="#photoshoot">Photoshoot</a> •
  <a href="#credits">Credits</a>
</p>

# **Abstract**

# **Methodology**

# **Data**

# **Photoshoot**

# **Creditst*

## KiCad design KiCAD/ChuaCircuit/ChuaCircuit.kicad_pcb

Parts:
+VCC1: J1; PinHeader_1x01_P2.54mm_Vertical
-VCC1: J1; PinHeader_1x01_P2.54mm_Vertical
C1: 10nF; C_0603_1608Metric
C2, C3: 100nF; C_1206_3216Metric
C4: .01u; C_0603_1608Metric
C5, C6, C8, C10: 0.1u; C_0603_1608Metric
C7, C9, C11: 0.01u; C_0603_1608Metric
CHUA_OUT1: Male_Header_1x1; PinHeader_1x01_P2.54mm_Vertical
GND2: TP4; PinHeader_1x01_P2.54mm_Vertical
OPA1: TL084; SOIC127P600X175-14N
OPA2: TL082; SOIC127P600X175-8N
R1, R2: 220; R_0603_1608Metric
R3: 2.2K; R_0603_1608Metric
R4, R5: 22K; R_0603_1608Metric
R6: 3.3K; R_0603_1608Metric
R7: 100; R_0603_1608Metric
R8, R9: 1K; R_0603_1608Metric
RV1: 5K; PinHeader_1x03_P2.54mm_Vertical
RV2: 5k; PinHeader_1x03_P2.54mm_Vertical
X1: TP3; PinHeader_1x01_P2.54mm_Vertical
Y1: TP2; PinHeader_1x01_P2.54mm_Vertical
Z1: TP1; PinHeader_1x01_P2.54mm_Vertical

Connections:
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, GND2.1, R3.1, R6.1, RV2.2, RV2.3
unnamed: -VCC1.1, C6.1, C7.1, OPA1.11 (V-)
unnamed: C3.1, OPA1.8, R9.1
unnamed: CHUA_OUT1.1, OPA2.1, OPA2.2 (-)
unnamed: OPA1.1, R1.1, R2.1
unnamed: OPA1.7, R4.2, R5.2
unnamed: OPA1.14, R7.1, R8.2, Z1.1
unnamed: C1.1, OPA1.3 (+), OPA1.5 (+), OPA2.3 (+), R1.2, R4.1, RV1.2, RV1.3, X1.1
unnamed: OPA1.2 (-), R2.2, R3.2
unnamed: OPA1.6 (-), R5.1, R6.2
unnamed: C2.1, OPA1.10 (+), R7.2, RV1.1, Y1.1
unnamed: OPA1.9 (-), OPA1.13 (-), R8.1, R9.2
unnamed: C3.2, OPA1.12 (+), RV2.1
unnamed: C10.1, C11.1, OPA2.4 (V-)
VCC: +VCC1.1, C4.1, C5.1, C8.1, C9.1, OPA1.4 (V+), OPA2.8 (V+)

Board: 2 copper layers, 29.5 x 31.0 mm, 31 parts (0 on the bottom side), 15 nets.

## Commit log

2025-11-16 Made platformio projects for transmitter and receiver
2025-11-20 Got base transmitter and reciever code to work and the wiring with rfm95w
2025-11-23 Fixed errors with schematic
2025-11-23 Updated PCB according to new changes
2025-11-23 Changed op-amp IC footprint to SMT style
2025-11-27 Fixed bug with simulation, now makes a double scroll pattern
2025-11-27 Removed unecessary files
2025-12-18 Moved pin header
2025-12-18 Updated backup
2025-12-18 Updated the LTspice simulation to include synchronization
2025-12-18 Ignore large simulation output files
2025-12-18 Remove raw simulation files from Git and LFS
2025-12-19 Add initial README.md with project details
2025-12-30 Updated spice sim
2025-12-30 Removed reciever and transmitter code
2025-12-30 Added dual op amp datasheet
2025-12-30 Added matlab sims of chua circuit
2026-01-01 Added double scroll picture
2026-01-01 Added pictures demonstrating the envelope
